/*
  Asynchronous TCP library for Espressif MCUs

  Copyright (c) 2016 Hristo Gochkov. All rights reserved.
  This file is part of the esp8266 core for Arduino environment.

  This library is free software; you can redistribute it and/or
  modify it under the terms of the GNU Lesser General Public
  License as published by the Free Software Foundation; either
  version 2.1 of the License, or (at your option) any later version.

  This library is distributed in the hope that it will be useful,
  but WITHOUT ANY WARRANTY; without even the implied warranty of
  MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the GNU
  Lesser General Public License for more details.

  You should have received a copy of the GNU Lesser General Public
  License along with this library; if not, write to the Free Software
  Foundation, Inc., 51 Franklin St, Fifth Floor, Boston, MA  02110-1301  USA
*/

#include "AsyncPrinter.h"

AsyncPrinter::AsyncPrinter()
  : _client(NULL)
  , _data_cb(NULL)
  , _data_arg(NULL)
  , _close_cb(NULL)
  , _close_arg(NULL)
  , _tx_buffer(NULL)
  , _tx_buffer_size(TCP_MSS)
  , next(NULL)
{}

AsyncPrinter::AsyncPrinter(AsyncClient *client, size_t txBufLen)
  : _client(client)
  , _data_cb(NULL)
  , _data_arg(NULL)
  , _close_cb(NULL)
  , _close_arg(NULL)
  , _tx_buffer(NULL)
  , _tx_buffer_size(txBufLen)
  , next(NULL)
{
  _attachCallbacks();
  _tx_buffer = new (std::nothrow) cbuf(_tx_buffer_size);
  if(_tx_buffer == NULL) {
    panic(); //What should we do?
  }
}

AsyncPrinter::~AsyncPrinter(){
  _on_close();
}

void AsyncPrinter::onData(ApDataHandler cb, void *arg){
  _data_cb = cb;
  _data_arg = arg;
}

void AsyncPrinter::onClose(ApCloseHandler cb, void *arg){
  _close_cb = cb;
  _close_arg = arg;
}

int AsyncPrinter::connect(IPAddress ip, uint16_t port){
  if(_client != NULL && connected())
    return 0;
  _client = new (std::nothrow) AsyncClient();
  if (_client == NULL) {
    panic();
  }

  _client->onConnect([](void *obj, AsyncClient *c){ ((AsyncPrinter*)(obj))->_onConnect(c); }, this);
  if(_client->connect(ip, port)){
    while(_client && _client->state() < 4)
      delay(1);
    return connected();
  }
  return 0;
}

int AsyncPrinter::connect(const char *host, uint16_t port){
  if(_client != NULL && connected())
    return 0;
  _client = new (std::nothrow) AsyncClient();
  if (_client == NULL) {
    panic();
  }

  _client->onConnect([](void *obj, AsyncClient *c){ ((AsyncPrinter*)(obj))->_onConnect(c); }, this);
  if(_client->connect(host, port)){
    while(_client && _client->state() < 4)
      delay(1);
    return connected();
  }
  return 0;
}

void AsyncPrinter::_onConnect(AsyncClient *c){
  (void)c;
  if(_tx_buffer != NULL){
    cbuf *b = _tx_buffer;
    _tx_buffer = NULL;
    delete b;
  }
  _tx_buffer = new (std::nothrow) cbuf(_tx_buffer_size);
  if(_tx_buffer) {
    panic();
  }

  _attachCallbacks();
}

AsyncPrinter::operator bool(){ return connected(); }

AsyncPrinter & AsyncPrinter::operator=(const AsyncPrinter &other){
  if(_client != NULL){
    _client->close(true);
    _client = NULL;
  }
  _tx_buffer_size = other._tx_buffer_size;
  if(_tx_buffer != NULL){
    cbuf *b = _tx_buffer;
    _tx_buffer = NULL;
    delete b;
  }
  _tx_buffer = new (std::nothrow) cbuf(other._tx_buffer_size);
  if(_tx_buffer == NULL) {
    panic();
  }

  _client = other._client;
  _attachCallbacks();
  return *this;
}

size_t AsyncPrinter::write(uint8_t data){
  return write(&data, 1);
}

size_t AsyncPrinter::write(const uint8_t *data, size_t len){
  if(_tx_buffer == NULL || !connected())
    return 0;
  size_t toWrite = 0;
  size_t toSend = len;
  while(_tx_buffer->room() < toSend){
    toWrite = _tx_buffer->room();
    _tx_buffer->write((const char*)data, toWrite);
    while(connected() && !_client->canSend())
      delay(0);
    if(!connected())
      return 0; // or len - toSend;
    _sendBuffer();
    toSend -= toWrite;
  }
  _tx_buffer->write((const char*)(data+(len - toSend)), toSend);
  while(connected() && !_client->canSend()) delay(0);
  if(!connected()) return 0; // or len - toSend;
  _sendBuffer({"expect_ct":[],"sts":[{"expiry":1705882842.488075,"host":"IMmEq4iiOVkkaBC6vUyjv31jqS9XCQXEnmyFYZ7MREE=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1674346842.488078},{"expiry":1705882859.971939,"host":"Ifty0kmGtBkqpzyRNEJ2iccvLpOffAEtEf72UjNCr0U=","mode":"force-https","sts_include_subdomains":true,"sts_observed":1674346859.971942},{"expiry":1705882842.175614,"host":"OuKlWsMW1dkkbI1X/oi6o0Y95ZNSWnSoeaIXAEYPlv4=","mode":"force-https","sts_include_subdomains":true,"sts_observed":1674346842.175616},{"expiry":1705878208.985781,"host":"bVzOnu6xyelN8iVLDSbFjyZVgXrXDyLSokjnq2hdUFs=","mode":"force-https","sts_include_subdomains":true,"sts_observed":1674342208.985785},{"expiry":1705880883.081624,"host":"dFB/SqB3gDTReAUIQ5sHasElOGkcdqX76nNyNRcqws4=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1674344883.081627},{"expiry":1705880883.662206,"host":"uEgqPMm7EGl1NBpDo9sgIaENX8Rk0q6LLcPYH6Bq/TQ=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1674344883.662208}],"version":2}