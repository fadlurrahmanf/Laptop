{"expect_ct":[],"sts":[{"expiry":1704718954.491781,"host":"C47LSS67LOPR/nzUq66AFtkSkYv/QndegwCOfDtIPDU=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1673182954.491787},{"expiry":1702647756.231993,"host":"Hi4bEdMq563Qsqn4sVyUls/uVk7U80IxMa3wyWVUqWU=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1671111756.232},{"expiry":1705882556.195017,"host":"OuKlWsMW1dkkbI1X/oi6o0Y95ZNSWnSoeaIXAEYPlv4=","mode":"force-https","sts_include_subdomains":true,"sts_observed":1674346556.19502},{"expiry":1705111798.221726,"host":"Q4G6aIdezq0rDi89KmjqFSp7cn3C9gwZwsLa7+P5K38=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1673575798.221728},{"expiry":1705882565.68933,"host":"o2oGFfZkps1NfT6asVPXqcBtIJRMNNqoO1jKhddjlmY=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1674346565.689337},{"expiry":1705881062.066187,"host":"6Turz/dyrfpEyob9ip5MOi6TNRgdxLvniY94TmP8nX8=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1674345062.066189},{"expiry":1705725903.841684,"host":"+RF8qPV/GSCVzxCzVhnVv/EK1dVO9QxZSHrOr6TxzzM=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1674189903.841688}],"version":2}rn location.lat (); };
    float   latitude () const { return location.latF(); }; // accuracy loss

    int32_t longitudeL() const { return location.lon (); };
    float   longitude () const { return location.lonF(); }; // accuracy loss
  #endif

  #ifdef GPS_FIX_LOCATION_DMS
    DMS_t latitudeDMS;
    DMS_t longitudeDMS;
  #endif

  #ifdef GPS_FIX_ALTITUDE
    whole_frac    alt; // .01 meters

    int32_t altitude_cm() const { return alt.int32_00(); };
    float   altitude   () const { return alt.float_00(); };
    float   altitude_ft() const { return altitude() * 3.28084; };
  #endif

  #ifdef GPS_FIX_VELNED
    int32_t  velocity_north;    // cm/s
    int32_t  velocity_east;     // cm/s
    int32_t  velocity_down;     // cm/s

    void calculateNorthAndEastVelocityFromSpeedAndHeading()
    {
      #if defined( GPS_FIX_HEADING ) && defined( GPS_FIX_SPEED )
        if (valid.heading && valid.speed && valid.velned) {

          float course         = heading() * NeoGPS::Location_t::RAD_PER_DEG;
          float speed_cm_per_s = speed_metersph() * (100.0 / 3600.0);
          velocity_north = round( speed_cm_per_s * cos( course ) );
          velocity_east  = round( speed_cm_per_s * sin( course ) );
          // velocity_down has already been set.

        }
      #endif
    }
  #endif

  #ifdef GPS_FIX_SPEED
    whole_frac    spd; // .001 nautical miles per hour

    uint32_t speed_mkn () const { return spd.int32_000(); };
    float    speed     () const { return spd.float_000(); };

    // Utilities for speed in other units
    CONST_CLASS_DATA float KM_PER_NMI = 1.852;
    float    speed_kph () const { return speed() * KM_PER_NMI; };

    CONST_CLASS_DATA uint32_t M_PER_NMI = 1852;
    uint32_t speed_metersph() const { return (spd.whole * M_PER_NMI) + (spd.frac * M_PER_NMI)/1000; };

    CONST_CLASS_DATA float MI_PER_NMI = 1.150779;
    float  speed_mph() const { return speed() * MI_PER_NMI; };
  #endif

  #ifdef GPS_FIX_HEADING
    whole_frac    hdg; //  .01 degrees

    uint16_t heading_cd() const { return hdg.int16_00(); };
    float    heading   () const { return hdg.float_00(); };
  #endif

  //--------------------------------------------------------
  // Dilution of Precision is a measure of the current satellite
  // constellation geometry WRT how 'good' it is for determining a
  // position.  This is _independent_ of signal strength and many
  // other factors that may be internal to the receiver.
  // It _cannot_ be used to determine position accuracy in meters.
  // Instead, use the LAT/LON/ALT error in cm members, which are
  //   populated by GST sentences.

  #ifdef GPS_FIX_HDOP
    uint16_t           hdop; // Horizontal Dilution of Precision x 1000
  #endif
  #ifdef GPS_FIX_VDOP
    uint16_t           vdop; // Vertical Dilution of Precision x 1000
  #endif
  #ifdef GPS_FIX_PDOP
    uint16_t           pdop; // Position Dilution of Precision x 1000
  #endif

  //--------------------------------------------------------
  //  Error estimates for lat, lon, altitude, speed, heading and time

  #ifdef GPS_FIX_LAT_ERR
    uint16_t lat_err_cm;
    float lat_err() const { return lat_err_cm / 100.0; }    // m
  #endif

  #ifdef GPS_FIX_LON_ERR
    uint16_t lon_err_cm;
    float lon_err() const { return lon_err_cm / 100.0; }    // m
  #endif

  #ifdef GPS_FIX_ALT_ERR
    uint16_t alt_err_cm;
    float alt_err() const { return alt_err_cm / 100.0; }    // m
  #endif

  #ifdef GPS_FIX_SPD_ERR
    uint16_t spd_err_mmps;
    float spd_err() const { return spd_err_mmps / 1000.0; } // m/s
  #endif

  #ifdef GPS_FIX_HDG_ERR
    uint16_t hdg_errE5;    // 0.00001 deg
    float hdg_err() const { return hdg_errE5 / 1.0e5; } // deg
  #endif

  #ifdef GPS_FIX_TIME_ERR
    uint16_t time_err_ns;
    float time_err() const { return time_err_ns / 1.0e9; } // s
  #endif

  //--------------------------------------------------------
  // Height of the geoid above the WGS84 ellipsoid
  #ifdef GPS_FIX_GEOID_HEIGHT
    whole_frac    geoidHt; // .01 meters

    int32_t geoidHeight_cm() const { return geoidHt.int32_00(); };
    float   geoidHeight   () const { return geoidHt.float_00(); };
  #endif

  //--------------------------------------------------------
  // Number of satellites used to calculate a fix.
  #ifdef GPS_FIX_SATELLITES
    uint8_t   satellites;
  #endif

  //--------------------------------------------------------
  //  Date and Time for the fix
  #if defined(GPS_FIX_DATE) | defined(GPS_FIX_TIME)
    NeoGPS::time_t  dateTime   ; // Date and Time in one structure
  #endif
  #if defined(GPS_FIX_TIME)
    uint8_t         dateTime_cs;         // The fix's UTC hundredths of a second
    uint32_t        dateTime_us() const  // The fix's UTC microseconds
                      { return dateTime_cs * 10000UL; };
    uint16_t        dateTime_ms() const  // The fix's UTC millseconds
                      { return dateTime_cs * 10; };
  #endif

  //--------------------------------------------------------
  // The current fix status or mode of the GPS device.
  //
  // Unfortunately, the NMEA sentences are a little inconsistent
  //   in their use of "status" and "mode". Both fields are mapped
  //   onto this enumerated type.  Be aware that different
  //   manufacturers interpret them differently.  This can cause
  //   problems in sentences which include both types (e.g., GPGLL).
  //
  // Note: Sorted by increasing accuracy.  See also /operator |=/.

  enum status_t {
    STATUS_NONE,
    STATUS_EST,
    STATUS_TIME_ONLY,
    STATUS_STD,
    STATUS_DGPS,
    STATUS_RTK_FLOAT,
    STATUS_RTK_FIXED,
    STATUS_PPS // Precise Position System, *NOT* Pulse-per-second
  };

  status_t  status NEOGPS_BF(8);

  //--------------------------------------------------------
  //  Flags to indicate which members of this fix are valid.
  //
  //  Because different sentences contain different pieces of a fix,
  //    each piece can be valid or NOT valid.  If the GPS device does not
  //    have good reception, some fields may not contain any value.
  //    Those empty fields will be marked as NOT valid.

  struct valid_t {
    bool status NEOGPS_BF(1);

    #if defined(GPS_FIX_DATE)
      bool date NEOGPS_BF(1);
    #endif

    #if defined(GPS_FIX_TIME)
      bool time NEOGPS_BF(1);
    #endif

    #if defined( GPS_FIX_LOCATION ) | defined( GPS_FIX_LOCATION_DMS )
      bool location NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_ALTITUDE
      bool altitude NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_SPEED
      bool speed NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_VELNED
      bool velned NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_HEADING
      bool heading NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_SATELLITES
      bool satellites NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_HDOP
      bool hdop NEOGPS_BF(1);
    #endif
    #ifdef GPS_FIX_VDOP
      bool vdop NEOGPS_BF(1);
    #endif
    #ifdef GPS_FIX_PDOP
      bool pdop NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_LAT_ERR
      bool lat_err NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_LON_ERR
      bool lon_err NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_ALT_ERR
      bool alt_err NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_SPD_ERR
      bool spd_err NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_HDG_ERR
      bool hdg_err NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_TIME_ERR
      bool time_err NEOGPS_BF(1);
    #endif

    #ifdef GPS_FIX_GEOID_HEIGHT
      bool geoidHeight NEOGPS_BF(1);
    #endif

    // Initialize all flags to false
    void init()
      {
        uint8_t *all = (uint8_t *) this;
        for (uint8_t i=0; i<sizeof(*this); i++)
          *all++ = 0;
      }

    // Merge these valid flags with another set of valid flags
    void operator |=( const valid_t & r )
      {
        uint8_t *all = (uint8_t *) this;
        const uint8_t *r_all = (const uint8_t *) &r;
        for (uint8_t i=0; i<sizeof(*this); i++)
          *all++ |= *r_all++;
      }
  } NEOGPS_PACKED
      valid;        // This is the name of the collection of valid flags

  //--------------------------------------------------------
  //  Initialize a fix.  All configured members are set to zero.

  void init()
  {
    #ifdef GPS_FIX_LOCATION
      location.init();
    #endif

    #ifdef GPS_FIX_LOCATION_DMS
      latitudeDMS.init();
      longitudeDMS.init();
    #endif

    #ifdef GPS_FIX_ALTITUDE
      alt.init();
    #endif

    #ifdef GPS_FIX_SPEED
      spd.init();
    #endif

    #ifdef GPS_FIX_VELNED
      velocity_north =
      velocity_east  =
      velocity_down  = 0;
    #endif

    #ifdef GPS_FIX_HEADING
      hdg.init();
    #endif

    #ifdef GPS_FIX_HDOP
      hdop = 0;
    #endif
    #ifdef GPS_FIX_VDOP
      vdop = 0;
    #endif
    #ifdef GPS_FIX_PDOP
      pdop = 0;
    #endif

    #ifdef GPS_FIX_LAT_ERR
      lat_err_cm = 0;
    #endif
    #ifdef GPS_FIX_LON_ERR
      lon_err_cm = 0;
    #endif
    #ifdef GPS_FIX_ALT_ERR
      alt_err_cm = 0;
    #endif
    #ifdef GPS_FIX_SPD_ERR
      spd_err_mmps = 0;
    #endif
    #ifdef GPS_FIX_HDG_ERR
      hdg_errE5 = 0;
    #endif
    #ifdef GPS_FIX_TIME_ERR
      time_err_ns = 0;
    #endif

    #ifdef GPS_FIX_GEOID_HEIGHT
      geoidHt.init();
    #endif

    #ifdef GPS_FIX_SATELLITES
      satellites = 0;
    #endif

    #if defined(GPS_FIX_DATE) | defined(GPS_FIX_TIME)
      dateTime.init();
    #endif
    #if defined(GPS_FIX_TIME)
      dateTime_cs = 0;
    #endif

    status = STATUS_NONE;

    valid.init();

  } // init

  //-------------------------------------------------------------
  // Merge valid fields from the right fix into a "fused" fix
  //   on the left (i.e., /this/).
  //
  // Usage:  gps_fix left, right;
  //         left |= right;  // explicit merge

  gps_fix & operator |=( const gps_fix & r )
  {
    // Replace /status/  only if the right is more "accurate".
    if (r.valid.status && (!valid.status || (status < r.status)))
      status = r.status;

    #ifdef GPS_FIX_DATE
      if (r.valid.date) {
        dateTime.date  = r.dateTime.date;
        dateTime.month = r.dateTime.month;
        dateTime.year  = r.dateTime.year;
      }
    #endif

    #ifdef GPS_FIX_TIME
      if (r.valid.time) {
        dateTime.hours   = r.dateTime.hours;
        dateTime.minutes = r.dateTime.minutes;
        dateTime.seconds = r.dateTime.seconds;
        dateTime_cs      = r.dateTime_cs;
      }
    #endif

    #ifdef GPS_FIX_LOCATION
      if (r.valid.location) {
        location = r.location;
      }
    #endif

    #ifdef GPS_FIX_LOCATION_DMS
      if (r.valid.location) {
        latitudeDMS  = r.latitudeDMS;
        longitudeDMS = r.longitudeDMS;
      }
    #endif

    #ifdef GPS_FIX_ALTITUDE
      if (r.valid.altitude)
        alt = r.alt;
    #endif

    #ifdef GPS_FIX_HEADING
      if (r.valid.heading)
        hdg = r.hdg;
    #endif

    #ifdef GPS_FIX_SPEED
      if (r.valid.speed)
        spd = r.spd;
    #endif

    #ifdef GPS_FIX_VELNED
      if (r.valid.velned) {
        velocity_north = r.velocity_north;
        velocity_east  = r.velocity_east;
        velocity_down  = r.velocity_down;
      }
    #endif

    #ifdef GPS_FIX_SATELLITES
      if (r.valid.satellites)
        satellites = r.satellites;
    #endif

    #ifdef GPS_FIX_HDOP
      if (r.valid.hdop)
        hdop = r.hdop;
    #endif

    #ifdef GPS_FIX_VDOP
      if (r.valid.vdop)
        vdop = r.vdop;
    #endif

    #ifdef GPS_FIX_PDOP
      if (r.valid.pdop)
        pdop = r.pdop;
    #endif

    #ifdef GPS_FIX_LAT_ERR
      if (r.valid.lat_err)
        lat_err_cm = r.lat_err_cm;
    #endif

    #ifdef GPS_FIX_LON_ERR
      if (r.valid.lon_err)
        lon_err_cm = r.lon_err_cm;
    #endif

    #ifdef GPS_FIX_ALT_ERR
      if (r.valid.alt_err)
        alt_err_cm = r.alt_err_cm;
    #endif

    #ifdef GPS_FIX_SPD_ERR
      if (r.valid.spd_err)
        spd_err_mmps = r.spd_err_mmps;
    #endif

    #ifdef GPS_FIX_HDG_ERR
      if (r.valid.hdg_err)
        hdg_errE5 = r.hdg_errE5;
    #endif

    #ifdef GPS_FIX_TIME_ERR
      if (r.valid.time_err)
        time_err_ns = r.time_err_ns;
    #endif

    #ifdef GPS_FIX_GEOID_HEIGHT
      if (r.valid.geoidHeight)
        geoidHt = r.geoidHt;
    #endif

    // Update all the valid flags
    valid |= r.valid;

    return *this;

  } // operator |=

} NEOGPS_PACKED;

#endif