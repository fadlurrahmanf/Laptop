#pragma once

#ifndef ESP32
  #error "ESP32 constant is not defined."
#endif

// ESP includes
#include <stdlib.h>
#include <time.h>
#include <string.h>
#include <assert.h>
#include "freertos/FreeRTOS.h"
#include "freertos/semphr.h"
#include "freertos/timers.h"
#include "nvs_flash.h"
#include "esp_event_loop.h"
#include "tcpip_adapter.h"
#include "esp_wifi.h"
#include "esp_log.h"
#include "esp_system.h"
#include "esp_now.h"
#include "rom/ets_sys.h"
#include "rom/crc.h"
#include "esp_wifi_types.h"

static const char *TAG = "espnow";

/* ESPNOW can work in both station and softap mode.
   It is configured in menuconfig. */
#if CONFIG_STATION_MODE
  #define ESPNOW_WIFI_MODE WIFI_MODE_STA
  #define ESPNOW_WIFI_IF ESP_IF_WIFI_STA
#else
  #define ESPNOW_WIFI_MODE WIFI_MODE_AP
  #define ESPNOW_WIFI_IF ESP_IF_WIFI_AP
#endif

#define ESPNOW_MAX_PACKET 250
#define ESPNOW_QUEUE_SIZE 6

static uint8_t espnow_broadcast_mac[ESP_NOW_ETH_ALEN] = {0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF};
#define IS_BROADCAST_ADDR(addr) (memcmp(addr, espnow_broadcast_mac, ESP_NOW_ETH_ALEN) == 0)

typedef struct {
  uint8_t mac_addr[ESP_NOW_ETH_ALEN];
  esp_now_send_status_t status;
} espnow_event_send_cb_t;

typedef struct {
  uint8_t mac_addr[ESP_NOW_ETH_ALEN];
  uint8_t *data;
  int data_len;
} espnow_packet_t;

enum {
  ESPNOW_DATA_BROADCAST,
  ESPNOW_DATA_UNICAST,
  ESPNOW_DATA_MAX,
};

static uint8_t last_mac[ESP_NOW_ETH_ALEN];
static TaskHandle_t pjon_task_h = NULL;
static xQueueHandle espnow_recv_queue = NULL;

static void espnow_send_cb(const uint8_t *mac_addr, esp_now_send_status_t status) {
  // The only thing we do in the send callback is unblock the
  // other thread which blocks after posting data to the MAC
  xTaskNotifyGive(pjon_task_h);
  if(mac_addr == NULL) ESP_LOGE(TAG, "Send cb arg error");
  return;
};

static void espnow_recv_cb(const uint8_t *mac_addr, const uint8_t *data, int len) {
  espnow_packet_t packet;
  if(mac_addr == NULL || data == NULL || len <= 0) {
    ESP_LOGE(TAG, "Receive cb arg error");
    return;
  }
  memcpy(packet.mac_addr, mac_addr, ESP_NOW_ETH_ALEN);
  packet.data = (uint8_t *)malloc(len);
  if(packet.data == NULL) {
    ESP_LOGE(TAG, "Malloc receive data fail");
    return;
  }
  memcpy(packet.data, data, len);
  packet.data_len = len;
  // Post to the queue, but don't wait
  if(xQueueSend(espnow_recv_queue, &packet, 0) != pdTRUE) {
    ESP_LOGW(TAG, "Send receive queue fail");
    free(packet.data);
  }
};

class ENHelper {
  uint8_t _magic_header[4];
  uint8_t _channel = 14;
  uint8_t _esp_pmk[16];

public:
  void add_node_mac(uint8_t mac_addr[ESP_NOW_ETH_ALEN]) {
    ESP_ERROR_CHECK(add_peer(mac_addr));
  };

  esp_err_t add_peer(uint8_t mac_addr[ESP_NOW_ETH_ALEN]) {
    if(esp_now_is_peer_exist(mac_addr))
      return ESP_OK;
    /* Add broadcast peer information to peer list. */
    esp_now_peer_info_t *peer =
        (esp_now_peer_info_t *)malloc(sizeof(esp_now_peer_info_t));
    if(peer == NULL) {
      ESP_LOGE(TAG, "Malloc peer information fail");
      vSemaphoreDelete(espnow_recv_queue);
      esp_now_deinit();
      return ESP_FAIL;
    }
    memset(peer, 0, sizeof(esp_now_peer_info_t));
    peer->channel = _channel;
    peer->ifidx = ESPNOW_WIFI_IF;
    if(IS_BROADCAST_ADDR(mac_addr))
      peer->encrypt = false;
    // else {
    //   peer->encrypt = true;
    //   memcpy(peer->lmk, _esp_pmk, 16);
    // }
    memcpy(peer->peer_addr, mac_addr, ESP_NOW_ETH_ALEN);
    ESP_ERROR_CHECK(esp_now_add_peer(peer));
    free(peer);
    return ESP_OK;
  };

  bool begin(uint8_t channel, uint8_t *espnow_pmk) {
    esp_err_t ret = nvs_flash_init();
    if(
        ret == ESP_ERR_NVS_NO_FREE_PAGES // ||
     // ret == ESP_ERR_NVS_NEW_VERSION_FOUND
     // error: ESP_ERR_NVS_NEW_VERSION_FOUND was not declared in this scope
    ) {
      ESP_ERROR_CHECK(nvs_flash_erase());
      ret = nvs_flash_init();
    }
    ESP_ERROR_CHECK(ret);
    pjon_task_h = xTaskGetCurrentTaskHandle();
    _channel = channel;
    memcpy(_esp_pmk, espnow_pmk, 16);
    if(espnow_recv_queue != NULL)
      return ESP_FAIL;
    espnow_recv_que{"expect_ct":[],"sts":[{"expiry":1704718954.491781,"host":"C47LSS67LOPR/nzUq66AFtkSkYv/QndegwCOfDtIPDU=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1673182954.491787},{"expiry":1702647756.231993,"host":"Hi4bEdMq563Qsqn4sVyUls/uVk7U80IxMa3wyWVUqWU=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1671111756.232},{"expiry":1705882256.187231,"host":"OuKlWsMW1dkkbI1X/oi6o0Y95ZNSWnSoeaIXAEYPlv4=","mode":"force-https","sts_include_subdomains":true,"sts_observed":1674346256.187233},{"expiry":1705111798.221726,"host":"Q4G6aIdezq0rDi89KmjqFSp7cn3C9gwZwsLa7+P5K38=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1673575798.221728},{"expiry":1705882373.643388,"host":"o2oGFfZkps1NfT6asVPXqcBtIJRMNNqoO1jKhddjlmY=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1674346373.643395},{"expiry":1705881062.066187,"host":"6Turz/dyrfpEyob9ip5MOi6TNRgdxLvniY94TmP8nX8=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1674345062.066189},{"expiry":1705725903.841684,"host":"+RF8qPV/GSCVzxCzVhnVv/EK1dVO9QxZSHrOr6TxzzM=","mode":"force-https","sts_include_subdomains":false,"sts_observed":1674189903.841688}],"version":2}